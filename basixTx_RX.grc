options:
  parameters:
    author: Siddhant Jinturkar
    generate_options: qt_gui
    id: basi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_probe_avg_mag_sqrd_x_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '1'
    threshold: '0'
    type: f
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 105e3
    low_cutoff_freq: 95e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Siddhant Jinturkar\OneDrive\Desktop\iqdata_150_30deg.cfile
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      from gnuradio import gr
      import os

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Power Logger",
                  in_sig=[np.float32],
                  out_sig=[]
              )

              self.tx_gain = 20
              self.rx_gain = 30
              self.filename = "power_log.csv"
              self.logged_header = False

              # Buffer to hold samples
              self.buffer = []
              self.batch_size = 200000  # Log once per 10,000 samples

          def write_header(self):
              with open(self.filename, 'a') as f:
                  f.write("timestamp,tx_gain,rx_gain,avg_power_dB\n")

          def work(self, input_items, output_items):
              in0 = input_items[0]
              self.buffer.extend(in0.tolist())

              if len(self.buffer) >= self.batch_size:
                  # Compute average power
                  avg_power = np.mean(self.buffer[:self.batch_size])
                  timestamp = time.time()

                  with open(self.filename, 'a') as f:
                      if not self.logged_header:
                          self.write_header()
                          self.logged_header = True
                      f.write(f"{timestamp},{self.tx_gain},{self.rx_gain},{avg_power:.4f}\n")

                  # Remove used samples
                  self.buffer = self.buffer[self.batch_size:]

              return len(in0)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.4e9
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 3.3e9
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', analog_probe_avg_mag_sqrd_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
