options:
  parameters:
    author: Siddhant Jinturkar
    generate_options: qt_gui
    id: tx_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Siddhant Jinturkar\OneDrive\Desktop\5G Research\white_noise_burst.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 3.3e9
    gain0: '60'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
